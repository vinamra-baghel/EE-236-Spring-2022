Vinamra Baghel 190010070 Part 1 Id-Vds Characteristics

.include ALD1105N.txt

*Netlist
M1 d g s b ALD1105N
Vgs g s dc 2.5
Vds d s dc 0
Vsb s b dc 0
Vb b 0 dc 0

*Analysis
.dc Vds 0 5 0.001 Vgs 2.5 4 0.5

.control
run
set color0 = white
set color1 = black
set color2 = red
set color3 = blue
set color4 = green
set color5 = orange
set xbrushwidth = 3

let Id1 = -I(Vds)[0, 5000]
let Id2 = -I(Vds)[5001, 10001]
let Id3 = -I(Vds)[10002, 15002]
let Id4 = -I(Vds)[15003, 20003]
let Vds1 = V(d)[0, 5000]
let Vds2 = V(d)[5001, 10001]
let Vds3 = V(d)[10002, 15002]
let Vds4 = V(d)[15003, 20003]
plot Id1 vs Vds1 Id2 vs Vds2 Id3 vs Vds3 Id4 vs Vds4

meas dc i11 find Id1 when Vds1 = 2m
meas dc i12 find Id1 when Vds1 = 5m
let rds1 = 3m/(i12-i11)
meas dc i21 find Id2 when Vds2 = 2m
meas dc i22 find Id2 when Vds2 = 5m
let rds2 = 3m/(i22-i21)
meas dc i31 find Id3 when Vds3 = 2m
meas dc i32 find Id3 when Vds3 = 5m
let rds3 = 3m/(i32-i31)
meas dc i41 find Id4 when Vds4 = 2m
meas dc i42 find Id4 when Vds4 = 5m
let rds4 = 3m/(i42-i41)

print rds1 rds2 rds3 rds4

meas dc i511 find Id1 when Vds1 = 4900m
meas dc i512 find Id1 when Vds1 = 5
let Vo1 = (4900m*i512-5*i511)/(i512-i511)
let ro1 = 100m/(i512-i511)
meas dc i521 find Id2 when Vds2 = 4900m
meas dc i522 find Id2 when Vds2 = 5
let Vo2 = (4900m*i522-5*i521)/(i522-i521)
let ro2 = 100m/(i522-i521)
meas dc i531 find Id3 when Vds3 = 4900m
meas dc i532 find Id3 when Vds3 = 5
let Vo3 = (4900m*i532-5*i531)/(i532-i531)
let ro3 = 100m/(i532-i531)
meas dc i541 find Id4 when Vds4 = 4900m
meas dc i542 find Id4 when Vds4 = 5
let Vo4 = (4900m*i542-5*i541)/(i542-i541)
let ro4 = 100m/(i542-i541)

print Vo1 Vo2 Vo3 Vo4
print ro1 ro2 ro3 ro4
.endc
.end
